# IAR project EZPro100_v20.ewp, settings and files
configuration STM3210E-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EZPro100_APP_v20.srec
  ILINK.IlinkOutputFile: EZPro100_v20.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210B-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: STM3210B-EVAL_EZPro100_v20.bin
configuration STM3210C-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: STM3210C-EVAL_EZPro100_v20.bin
configuration STM3210E-EVAL_XL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxG ST STM32F10xxG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_XL; USE_STM3210E_EVAL
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: STM3210E-EVAL_XL_EZPro100_v20.bin
configuration STM32L152-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; USE_STM32L152_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM32L152_EVAL
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: STM32L152-EVAL_EZPro100_v20.bin
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../src/: system_stm32f10x.c system_stm32l1xx.c
  group Doc
    ../: readme.txt
  group EWARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/iar/: startup_stm32l1xx_md.s
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_ioe.c
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
  group STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group STM32F10x_StdPeriph_Driver/USB-FS-Device_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32L1xx_StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_syscfg.c stm32l1xx_usart.c
  group User
    ../src/: ADC.c Config.c global.c hw_config.c IRC.c lcd.c M201IRC.C main.c MC20P02BPro.c MC20P38IRC.C MC20P38Pro.c MC224BPro.c MC301Pro.c MC30P6060.c MC32P21Pro.c MC32P5222Pro.c MC32P7011.c MC32P7022.c MC32P7311.c MC32T8132.c MC33P116Pro.c MC9033.c OTPRW.c OTPRW_8K.C power.c spi.c stm32f10x_it.c test.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c USB_Rx_Tx.c wx_i2c.c
